# Keil uVision project Mc.uvprojx, settings and files
target TLE9879_EvalKit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TLE9871QXA20 Infineon
  pack: Infineon.TLE987x_DFP.1.5.0
  cpu: IRAM(0x18000018,0xBE8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x7FFC) IROM2(0x11007FFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: McSd +hex
  AfterMake: cmd /c copy Objects\Mc.hex PRODUCT_LXT3674_230514_SV1.0_HV1.0_3.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\app;.\Simulink\AppMain_ert_rtw;.\Common;.\Drv;.\Mc;.\Test
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x7fe8
  memory RVCT5: ROM 0x11007fe8 size 0x18
  memory RVCT9: RAM 0x18000018 size 0xbe8
  memory RVCT10: RAM 0x18000000 size 0x10
  link misc: --diag_suppress L6918
  group App
    ./app/: Main.c MotorAPI.c DTC.c FanComTest.c GlobalVars.c ErtMain.c FctTest.c TerminalTest.c MotorDiagCurrent.c MotorDiagSpeed.c MotorDiagBEMF.c MotorDiagPreStart.c UartDebug.c
  group Mc
    ./Mc/: Mc.c McCfg.c McPhaseOffset.c McLowTask.c McLib.c McHighTask.c
    ./: McSd.lib
  group Drv
    ./Drv/: SDK.c SdkCfg.c DrvAdc.c DrvIsr.c DrvPwmIn.c
  group Simulink
    ./Simulink/AppMain_ert_rtw/: AppMain.c AppMain_data.c ECUFaultDiag.c FeedBack.c MotorRestartAndFaultCnt.c MotorTargetSpeedMux.c PwmInParamEval.c PwmInTargetSpeedEval.c SleepMode.c rt_sys_ECUFaultDiag_1.c
  group Common
    ./Common/: Common.c Table.c
software components: CMSIS:CORE 4.1.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.8, Device:SDK:ADC2 0.2.5, Device:SDK:BDRV 0.4.8, Device:SDK:BOOTROM 0.3.0, Device:SDK:CCU6 0.3.2, Device:SDK:CSA 0.1.7, Device:SDK:DMA 0.2.2, Device:SDK:GPT12E 0.2.0, Device:SDK:INT 0.2.2, Device:SDK:ISR 0.2.8, Device:SDK:LIN 0.1.9, Device:SDK:MON 0.1.6, Device:SDK:PMU 0.2.0, Device:SDK:PORT 0.5.7, Device:SDK:SCU 0.5.4, Device:SDK:SSC 0.1.7, Device:SDK:TIMER2x 0.2.1, Device:SDK:TIMER3 0.1.7, Device:SDK:UART 0.2.2, Device:SDK:WDT1 0.3.2, Device:Startup 1.1.0
