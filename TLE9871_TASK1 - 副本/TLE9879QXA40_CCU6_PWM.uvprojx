# Keil uVision project TLE9879QXA40_CCU6_PWM.uvprojx, settings and files
target TLE9879_EvalKit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TLE9871QXA20 Infineon
  pack: Infineon.TLE987x_DFP.1.5.0
  cpu: IRAM(0x18000018,0xBE8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x7FFC) IROM2(0x11007FFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CCU6_PWM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Function\MOTOR;.\Function\ADC;.\Function\PWM_OUT;.\Function\MY_UART
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x7ffc
  memory RVCT5: ROM 0x11007ffc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0xbe8
  memory RVCT10: RAM 0x18000000 size 0x10
  group App
    ./app/: main.c
  group Fun
    ./Function/MOTOR/: motor.c
    ./Function/ADC/: adc.c
    ./Function/PWM_CAPTURE/: pwm_capture.c
    ./Function/PWM_OUT/: pwm_out.c
    ./Function/MY_UART/: my_uart.c
software components: CMSIS:CORE 5.4.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.8, Device:SDK:ADC2 0.2.5, Device:SDK:BDRV 0.4.8, Device:SDK:BOOTROM 0.3.0, Device:SDK:CCU6 0.3.2, Device:SDK:CSA 0.1.7, Device:SDK:GPT12E 0.2.0, Device:SDK:INT 0.2.2, Device:SDK:ISR 0.2.8, Device:SDK:LIN 0.1.9, Device:SDK:PMU 0.2.0, Device:SDK:PORT 0.5.7, Device:SDK:SCU 0.5.4, Device:SDK:TIMER2x 0.2.1, Device:SDK:UART 0.2.2, Device:SDK:WDT1 0.3.2, Device:Startup 1.1.0
